# Keil uVision project timer_example.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: timer_example +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: config.h gpio.c gpio.h register.h timer.h timer.c typedef.h main.c
